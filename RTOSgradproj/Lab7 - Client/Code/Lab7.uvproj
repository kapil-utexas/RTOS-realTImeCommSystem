# Keil uVision project Lab7.uvproj, settings and files
target Lab7 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: CAN
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c main.c Timer3.c can.c can0.c interrupt.c ADC.c diskio.c ff.c FIFO.c fixed.c Heartbeat.c Interpreter.c OS.c OS_PeriodicTasks.c OS_Switch.c OS_Time.c ST7735.c UART.c Ping.c osasm.s DCMotor.c LinearInterpolation.c TestMain.c IR.c PWM.c cr4_fft_64_stm32.s esp8266.c LED.c
